# Keil uVision project sample.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  link misc: REMOVEUNUSED
  group usr
    ./Sources/src/: main.c Task.c System_init.c
    ./: 功能说明.txt
  group isr
    ./Sources/isr/: STC32G_Timer_Isr.c
  group app
    ./Sources/src/: adc.c app.c app_adcKey.c app_display.c app_MatrixKey.c app_ntc.c app_rtc.c
